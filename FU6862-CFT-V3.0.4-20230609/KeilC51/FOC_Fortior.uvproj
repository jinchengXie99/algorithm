# Keil uVision project FOC_Fortior.uvproj, settings and files
target FU6862_FOC (MCS-51)
  device: FU68XX Fortior Tech
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: Fortior_FU6862 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\User\Include;..\FU68xx_Hardware_Driver\Include
  link misc: REMOVEUNUSED
  group Apllication
    ../User/Source/Application/: main.c Interrupt.c AddFunction.c LED.c
    ../User/Source/Function/: KeyScan.c
    ../User/Include/: Customer.h Develop.h Protect.h HeaterControl.h
  group Function
    ../User/Source/Function/: MotorControl.c MotorControlFunction.c MotorProtect.c BEMFDetect.c FOCTailDect.c RPD.c StartupInitandSwitch.c SMDU.c
  group Hardware
    ../User/Source/Hardware/: AMPInit.c DriverInit.c EXTIInit.c SPIInit.c TimerInit.c ADCInit.c CMPInit.c GPIOInit.c PIInit.c UARTInit.c
    ../User/Source/Function/: Flash.c
  group FU68XX_Hardware_Driver
    ../FU68xx_Hardware_Driver/Source/: FU68xx_2_DMA.c FU68xx_2_System.c Fu68xx_2_Other.LIB Startup.LIB STARTUP_FU6802.A51
  group Document
    ../Document/: DebugLog.txt Versionlog.txt
